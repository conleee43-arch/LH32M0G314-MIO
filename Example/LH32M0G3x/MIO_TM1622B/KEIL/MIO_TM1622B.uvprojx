# Keil uVision project MIO_TM1622B.uvprojx, settings and files
target Target 1 (6240000::V6.24::ARMCLANG)
  device: LH32M0G3x LegendSemi
  pack: LegendSemi.LH32M0G3x_DFP.1.0.2
  cpu: IRAM(0x20000000,0x2000) IROM(0x08000000,0x20000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: MIO_TM1622B +hex
  c flags: Optim=2 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=3
  c include: ..\..\..\..\Device\LH32M0G3X;..\..\..\..\Drivers\CMSIS\Core\Include;..\..\..\..\Drivers\LHL\LH32M0G3x\inc;..\;..\hardware
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x1e000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group user
    ../: main.c lh32m0xx_it.c
    ../hardware/: tm1622b_driver.c
  group lhl
    ../../../../Drivers/LHL/LH32M0G3x/lib/: lh32m0g3x_adc.c lh32m0g3x_btim.c lh32m0g3x_crc.c lh32m0g3x_dac.c lh32m0g3x_dma.c lh32m0g3x_dmamux.c lh32m0g3x_eeprom.c lh32m0g3x_exti.c lh32m0g3x_flash.c lh32m0g3x_gpio.c lh32m0g3x_i2c.c lh32m0g3x_iwdg.c lh32m0g3x_lptim.c lh32m0g3x_mcal.c lh32m0g3x_rcc.c lh32m0g3x_rtc.c lh32m0g3x_spi.c lh32m0g3x_timer.c lh32m0g3x_uart.c lh32m0g3x_lhl.c lh32m0g3x_mio.c lh32m0g3x_power.c
  group startup
    ../../../../Device/LH32M0G3X/KEIL/: startup_lh32m0g3x.s
    ../../../../Device/LH32M0G3X/: system_lh32m0g3x.c
